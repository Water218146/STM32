# Keil uVision project 2024_H_Car.uvprojx, settings and files
target 2024_H_Car (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 2024_H_Car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../User/Module/Ringbuffer;../User/Module/Grayscale;../User/Module/Ebtn;..\User\Module\0.96 Oled;../User/Module/PID;..\User\Module\MPU6050;../User/Driver;../User/App;../User
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group User/Module/Ebtn
    ../User/Module/Ebtn/: ebtn.c
  group User/Module/Ringbuffer
    ../User/Module/Ringbuffer/: ringbuffer.c
  group User/Module/0.96 Oled
    ../User/Module/0.96 Oled/: oled.c oled_font.c
  group User/Module/Grayscale
    ../User/Module/Grayscale/: hardware_iic.c
  group User/Module/PID
    ../User/Module/PID/: pid.c
  group User/Module/MPU6050
    ../User/Module/MPU6050/: IIC.c inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c
  group User/Driver
    ../User/Driver/: encoder_driver.c key_driver.c led_driver.c motor_driver.c oled_driver.c uart_driver.c mpu6050_driver.c
  group User/App
    ../User/App/: encoder_app.c gray_app.c key_app.c led_app.c motor_app.c oled_app.c pid_app.c uart_app.c mpu6050_app.c
  group User
    ../User/: MyDefine.h Scheduler.c Scheduler_Task.c
software components: CMSIS:CORE 4.3.0
